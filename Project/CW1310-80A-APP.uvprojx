# Keil uVision project CW1310-80A-APP.uvprojx, settings and files
target CW1310-80A-APP (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F307VC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CW1310-72A-V1.3.1.1.axf +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_CL
  c include: ..\Firmware\GD32Driver\Include;..\Firmware\CMSIS\GD;..\Firmware\CMSIS\GD\GD32F30x\Include;..\User;..\CwDriver\Inc;..\SeggerRTT\RTT;..\UTEST_hard;..\APP\srv;..\BoardPackge;..\Middle;..\cf;..\APP;..\APP\protocol;..\APP\Diagnose;..\Peripheral\Inc;..\Peripheral\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8006000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group User
    ../User/: main.c systick.c CWDrv.h stdtype.h
    ./: ChangeList.txt
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group StarUp
    ../Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_cl.s
  group Peripheral
    ../Peripheral/Src/: BM22S2301.c ntc_tab.c ntc1.c ntc2.c RX8010.c
  group Diagnose
    ../APP/Diagnose/: pwr_node.c ntc_node.c
    ../APP/: selfdiag.c
  group APP
    ../APP/: valvectl.c LEDCtrl.c DiCtrl.c algo.c DoCtrl.c BatteryManage.c
  group protocol
    ../APP/protocol/: can_ep_handler.c candebug.c canboot.c can_ip_handler.c can_ep_01h.c
  group srv
    ../APP/srv/: Appconf.c message.c canbuffer.c kfifo_sp.c para.c time.c ifr.c
  group Firmware
    ../Firmware/GD32Driver/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group BoardPackge
    ../BoardPackge/: AdcCfg.c DioCfg.c
  group Middle
    ../Middle/: MidDio.c MidAdc.c MidCan.c MidWdg.c MidTimer.c MidUsart.c MidW25n01.c nvm.c MidM24C64.c
  group CWdrive
    ../CwDriver/Src/: DrvAdc.c DrvCAN.c DrvFlash.c DrvGpio.c DrvTimer.c DrvUsart.c DrvWdgt.c DrvSpi.c GpioMap.c DrvIIC.c
    ../UTEST_hard/: inflash.c
  group cf
    ../cf/: c_mem.c c_convert.c c_crc.c c_sort.c cbits.c cjcrc.c saecrc.c
  group RTT
    ../SeggerRTT/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 5.6.0
